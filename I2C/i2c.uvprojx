# Keil uVision project i2c.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: i2c.c i2c.h main.c uart.c uart.h
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
